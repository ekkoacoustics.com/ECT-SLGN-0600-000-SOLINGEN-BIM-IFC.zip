Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Solingen\ECT-SLGN-0600-000 SOLINGEN.IFC
Time: 2024-11-22T11:57:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 6.9016248000000013; Volume Measure: 0.0069016248000000; Area Measure: 1.2568484900397565

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 6.9016248000000013; Volume Measure: 0.0069016248000000; Area Measure: 1.2568484900397565

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 6.9016248000000013; Volume Measure: 0.0069016248000000; Area Measure: 1.2568484900397565

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ECT-SLGN-0600-000 SOLINGEN | PSet_Mass_Property - Mass Measure: 6.9016248000000013; Volume Measure: 0.0069016248000000; Area Measure: 1.2568484900397565
ECT-SLGN-0600-000 SOLINGEN
