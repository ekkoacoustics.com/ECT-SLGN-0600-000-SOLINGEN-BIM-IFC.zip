Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Solingen\ECT-SLGN-0600-000 SOLINGEN FULL ASSEMBLY.IFC
Time: 2024-11-22T11:58:47+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 27.6064992000000053; Volume Measure: 0.0276064992000000; Area Measure: 5.0273939601590270

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 27.6064992000000053; Volume Measure: 0.0276064992000000; Area Measure: 5.0273939601590270

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 27.6064992000000053; Volume Measure: 0.0276064992000000; Area Measure: 5.0273939601590270

# IfcBuildingElementProxy (5)
In: default BuildingStorey
Name
ECT-SLGN-0600-000 SOLINGEN FULL ASSEMBLY | PSet_Mass_Property - Mass Measure: 27.6064992000000053; Volume Measure: 0.0276064992000000; Area Measure: 5.0273939601590270
ECT-SLGN-0600-000 SOLINGEN
ECT-SLGN-0600-000 SOLINGEN-1
ECT-SLGN-0600-000 SOLINGEN-2
ECT-SLGN-0600-000 SOLINGEN-3
